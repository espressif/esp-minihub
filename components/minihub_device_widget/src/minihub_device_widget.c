/*
 * minihub_device_widget - runtime-loaded device control descriptor registry.
 *
 * The registry is parsed from a CSV (default /data/config/devices.csv, with a
 * compiled-in embedded fallback). See minihub_device_widget.h for the data-flow
 * contract. Strings are owned (strdup'd) so the table can be reloaded at runtime
 * without leaking or requiring a firmware rebuild for new device types.
 */
#include "minihub_device_widget.h"

#include <stddef.h>
#include <string.h>
#include <stdio.h>
#include <stdlib.h>
#include <sys/stat.h>
#include "esp_log.h"
#include "cJSON.h"
#include "freertos/FreeRTOS.h"
#include "freertos/semphr.h"

static const char *TAG = "dw";

/* Compiled-in fallback CSV (generated by tools/gen_device_widget.py). */
extern const char MINIHUB_DW_EMBEDDED_CSV[];

/* ---- runtime state ---- */
/* Layout MUST match minihub_device_widget_entry_t (same fields, same order,
 * same size) so the loader can reinterpret dw_entry_t* as that public type.
 * Do not add private-only fields here — they change the array stride and
 * corrupt every entries[j] read (seen as column-shifted /api/device_widgets). */
typedef struct {
    char *device;
    char *parameter;
    char *label;
    char *style_json;
    char *image;
    char *device_image;   /* device-class icon override (repeated per row) */
    /* No `visible`: that is a property of the registered point, not of the
     * type (see the header). No protocol field either: this catalog describes
     * how a device TYPE is rendered, and device display is protocol-independent.
     * The transport prefix is a property of the device REGISTRATION
     * (minihub_point_resolve_by_type_param). */
} dw_entry_t;

/* Compile-time guard: private row and public entry must stay binary-compatible
 * (same size AND field offsets). A stride/offset mismatch shifts every
 * entries[j] field and /api/device_widgets looks "column-smashed". */
_Static_assert(sizeof(dw_entry_t) == sizeof(minihub_device_widget_entry_t),
               "dw_entry_t must match minihub_device_widget_entry_t layout");
_Static_assert(offsetof(dw_entry_t, device) ==
                   offsetof(minihub_device_widget_entry_t, device),
               "dw_entry_t.device offset mismatch");
_Static_assert(offsetof(dw_entry_t, parameter) ==
                   offsetof(minihub_device_widget_entry_t, parameter),
               "dw_entry_t.parameter offset mismatch");
_Static_assert(offsetof(dw_entry_t, label) ==
                   offsetof(minihub_device_widget_entry_t, label),
               "dw_entry_t.label offset mismatch");
_Static_assert(offsetof(dw_entry_t, style_json) ==
                   offsetof(minihub_device_widget_entry_t, style_json),
               "dw_entry_t.style_json offset mismatch");
_Static_assert(offsetof(dw_entry_t, image) ==
                   offsetof(minihub_device_widget_entry_t, image),
               "dw_entry_t.image offset mismatch");
_Static_assert(offsetof(dw_entry_t, device_image) ==
                   offsetof(minihub_device_widget_entry_t, device_image),
               "dw_entry_t.device_image offset mismatch");

/* One immutable snapshot of the registry. A reload never mutates the active
 * snapshot in place: the new table is built first and then swapped in, so a
 * reader that already holds a pointer keeps reading a consistent table. */
typedef struct {
    dw_entry_t *entries;                    /* contiguous, owns strings */
    size_t entries_len;
    minihub_device_widget_device_t *views;  /* views over entries */
    size_t views_len;
} dw_table_t;

/* Concurrency: GET /api/device_widgets walks the table for the whole request
 * while PUT /api/dev/catalog/ (or a hub soft reload) can rebuild it on another
 * task, and the public accessors hand out INTERNAL pointers. Two guards:
 *   - s_mutex makes the pointer swap atomic and serialises reloads;
 *   - the previous snapshot is kept in s_retired and released only on the next
 *     swap, so a pointer handed out before a reload stays valid for at least
 *     one reload cycle (the table is tiny: ~10 rows).
 * See the header contract: pointers are valid until the next successful reload.
 * Lock order is one-way - nothing here calls back into minihub_point_*. */
static SemaphoreHandle_t s_mutex;
static dw_table_t s_active;
static dw_table_t s_retired;
static bool s_loaded;

/* CSV columns (resolved by header name at parse time, so order is flexible and
 * unrecognised columns are ignored - e.g. a legacy `protocol`/`transport`
 * column is tolerated and simply dropped). COL_N is the number of columns the
 * format expects; DW_CSV_MAX_COLS is the PARSE BUFFER size and is deliberately
 * larger so an extra hand-added column still maps by name instead of silently
 * truncating the row (which used to shift style/image into the wrong fields). */
/* No COL_VISIBLE: the flat registry carries no visibility - see the header.
 * A legacy `visible` column is still tolerated (unrecognised columns are
 * ignored), so an older /data/config/devices.csv keeps loading. */
enum { COL_DEVICE = 0, COL_PARAMETER, COL_STYLE, COL_IMAGE,
       COL_DEVICE_IMAGE, COL_N };
#define DW_CSV_MAX_COLS 16

/* ---- CSV parsing (RFC4180-ish, quoted fields, embedded commas/quotes) ---- */

/* Parse the next row from *cursor into out[DW_CSV_MAX_COLS] (each a malloc'd string, or
 * NULL when the column is absent). Advances *cursor past the row. Returns the
 * number of fields emitted (>=1) on success, -1 at end of input / blank
 * trailing line, or -2 on allocation failure (any out[i] already emitted for
 * the current row are freed before returning). The caller frees every non-NULL
 * out[i] on success, and treats -2 as fatal. */
static int dw_csv_next_row(const char **cursor, char *out[DW_CSV_MAX_COLS])
{
    const char *p = *cursor;
    for (int i = 0; i < DW_CSV_MAX_COLS; i++) {
        out[i] = NULL;
    }
    if (*p == '\0') {
        return -1;
    }

    int col = 0;
    char *fb = malloc(128);
    size_t fcap = 128, flen = 0;
    if (!fb) {
        return -2;
    }
    bool inq = false;

#define DW_EMIT() do {                                            \
        if (col < DW_CSV_MAX_COLS) {                              \
            out[col] = malloc(flen + 1);                         \
            if (out[col]) { memcpy(out[col], fb, flen); out[col][flen] = '\0'; } \
        }                                                        \
        col++; flen = 0;                                         \
    } while (0)

    for (;;) {
        char c = *p;
        if (c == '\0') {
            if (!(col == 0 && flen == 0)) {
                DW_EMIT();
            }
            free(fb);
            *cursor = p;
            return (col == 0) ? -1 : col;
        }
        if (c == '"') {
            if (inq && p[1] == '"') {        /* escaped quote inside quoted field */
                if (flen + 1 >= fcap) {
                    char *nb = realloc(fb, fcap * 2);
                    if (!nb) {
                        for (int k = 0; k < DW_CSV_MAX_COLS; k++) {
                            free(out[k]);
                        }
                        free(fb);
                        return -2;
                    }
                    fb = nb; fcap *= 2;
                }
                fb[flen++] = '"';
                p += 2;
                continue;
            }
            inq = !inq;
            p++;
            continue;
        }
        if (!inq && c == ',') {
            DW_EMIT();
            p++;
            continue;
        }
        if (!inq && (c == '\n' || c == '\r')) {
            if (c == '\r' && p[1] == '\n') {
                p++;          /* consume CRLF as one terminator */
            }
            DW_EMIT();
            p++;
            free(fb);
            *cursor = p;
            return col;
        }
        if (flen + 1 >= fcap) {
            char *nb = realloc(fb, fcap * 2);
            if (!nb) {
                for (int k = 0; k < DW_CSV_MAX_COLS; k++) {
                    free(out[k]);
                }
                free(fb);
                return -2;
            }
            fb = nb; fcap *= 2;
        }
        fb[flen++] = c;
        p++;
    }
#undef DW_EMIT
}

/* ---- build the in-memory table from CSV text ---- */

static int dw_entry_cmp(const void *a, const void *b)
{
    const dw_entry_t *x = a, *y = b;
    int d = strcmp(x->device, y->device);
    if (d) {
        return d;
    }
    return strcmp(x->parameter, y->parameter);
}

static void dw_entry_free(dw_entry_t *e)
{
    if (!e) {
        return;
    }
    free(e->device);
    free(e->parameter);
    free(e->label);
    free(e->style_json);
    free(e->image);
    free(e->device_image);
}

static void dw_table_free(dw_table_t *t)
{
    if (!t) {
        return;
    }
    if (t->entries) {
        for (size_t i = 0; i < t->entries_len; i++) {
            dw_entry_free(&t->entries[i]);
        }
        free(t->entries);
    }
    free(t->views);
    memset(t, 0, sizeof(*t));
}

/* ---- concurrency helpers ---- */

/* The registry is created after the scheduler runs (minihub_config_init calls
 * init() after the littlefs mount), but the public load() may also be called
 * directly (host tests), so the mutex is created on first use. */
static void dw_ensure_mutex(void)
{
    if (!s_mutex) {
        s_mutex = xSemaphoreCreateMutex();
    }
}

static void dw_lock(void)
{
    if (s_mutex) {
        xSemaphoreTake(s_mutex, portMAX_DELAY);
    }
}

static void dw_unlock(void)
{
    if (s_mutex) {
        xSemaphoreGive(s_mutex);
    }
}

/* Atomically make `next` the served table. The previously active snapshot moves
 * to s_retired (still readable by pointers handed out earlier) and the snapshot
 * retired one swap ago is finally released - that one can no longer be reached
 * because any reader that could hold it has already gone through a reload. */
static void dw_publish(dw_table_t *next)
{
    dw_ensure_mutex();
    dw_lock();
    dw_table_t dead = s_retired;
    s_retired = s_active;
    s_active = *next;
    s_loaded = true;
    dw_unlock();
    dw_table_free(&dead);   /* unreachable: free outside the lock */
    memset(next, 0, sizeof(*next));
}

/* Parse CSV text into `out` WITHOUT touching the served table. The caller
 * publishes the result only on success, so a rejected CSV leaves the previous
 * registry up instead of taking the console down with it. */
static esp_err_t dw_build(const char *text, dw_table_t *out)
{
    const char *cur = text;
    if (!text || !out) {
        return ESP_ERR_INVALID_ARG;
    }
    memset(out, 0, sizeof(*out));

    /* Read the header row and map column names -> positions. This makes the
     * format resilient to column reordering; unrecognised columns (e.g. a
     * legacy `protocol`) are ignored. */
    char *hdr[DW_CSV_MAX_COLS];
    int nh = dw_csv_next_row(&cur, hdr);
    if (nh < 0) {
        return (nh == -2) ? ESP_ERR_NO_MEM : ESP_ERR_INVALID_ARG;
    }
    if (nh > DW_CSV_MAX_COLS) {
        ESP_LOGW(TAG, "CSV header has %d columns (>%d); extra columns ignored",
                 nh, DW_CSV_MAX_COLS);
    }
    int c_dev = -1, c_par = -1, c_sty = -1, c_img = -1, c_dimg = -1;
    for (int i = 0; i < DW_CSV_MAX_COLS; i++) {
        if (hdr[i]) {
            if      (!strcasecmp(hdr[i], "device"))        c_dev  = i;
            else if (!strcasecmp(hdr[i], "parameter"))     c_par  = i;
            else if (!strcasecmp(hdr[i], "style"))         c_sty  = i;
            else if (!strcasecmp(hdr[i], "image"))         c_img  = i;
            else if (!strcasecmp(hdr[i], "device_image"))  c_dimg = i;
        }
        free(hdr[i]);
    }
    if (c_dev < 0 || c_par < 0) {
        return ESP_ERR_INVALID_ARG;   /* device + parameter are mandatory */
    }

    dw_entry_t *tmp = NULL;
    size_t tmp_cap = 0, tmp_len = 0;
    size_t unlabeled = 0;
    bool cols_warned = false;

    for (;;) {
        char *f[DW_CSV_MAX_COLS];
        int nf = dw_csv_next_row(&cur, f);
        if (nf < 0) {
            if (nf == -2) {
                goto oom;
            }
            break;
        }
        if (nf > DW_CSV_MAX_COLS && !cols_warned) {
            ESP_LOGW(TAG, "CSV row has %d columns (>%d); extra columns ignored",
                     nf, DW_CSV_MAX_COLS);
            cols_warned = true;
        }
        if (c_dev >= 0 && (!f[c_dev] || f[c_dev][0] == '\0')) {
            for (int i = 0; i < DW_CSV_MAX_COLS; i++) {
                free(f[i]);
            }
            continue;
        }

        dw_entry_t e;
        memset(&e, 0, sizeof(e));
        e.device     = (c_dev >= 0 && f[c_dev]) ? f[c_dev] : strdup("");
        if (c_dev >= 0) f[c_dev] = NULL;
        e.parameter  = (c_par >= 0 && f[c_par]) ? f[c_par] : strdup("");
        if (c_par >= 0) f[c_par] = NULL;
        e.image      = (c_img >= 0 && f[c_img]) ? f[c_img] : strdup("");
        if (c_img >= 0) f[c_img] = NULL;
        e.device_image = (c_dimg >= 0 && f[c_dimg]) ? f[c_dimg] : strdup("");
        if (c_dimg >= 0) f[c_dimg] = NULL;
        e.style_json = (c_sty >= 0 && f[c_sty]) ? f[c_sty] : strdup("{}");
        if (c_sty >= 0) f[c_sty] = NULL;

        for (int i = 0; i < DW_CSV_MAX_COLS; i++) {
            if (f[i]) {
                free(f[i]);
            }
        }

        /* e->label is the default language only: style_json.labels.zh, falling
         * back to the parameter name. The per-request language pick happens
         * when /api/device_widgets serialises the entry, not here. */
        e.label = NULL;
        cJSON *root = cJSON_Parse(e.style_json);
        if (root) {
            cJSON *labels = cJSON_GetObjectItemCaseSensitive(root, "labels");
            cJSON *l = labels ? cJSON_GetObjectItemCaseSensitive(labels, "zh") : NULL;
            if (cJSON_IsString(l) && l->valuestring) {
                e.label = strdup(l->valuestring);
            } else if (!labels) {
                unlabeled++;
            }
            cJSON_Delete(root);
        }
        if (!e.label) {
            e.label = strdup(e.parameter[0] ? e.parameter : e.device);
        }

        if (!e.device || !e.parameter || !e.style_json || !e.image ||
            !e.device_image || !e.label) {
            dw_entry_free(&e);
            goto oom;
        }

        if (tmp_len == tmp_cap) {
            size_t nc = tmp_cap ? tmp_cap * 2 : 16;
            dw_entry_t *nt = realloc(tmp, nc * sizeof(*tmp));
            if (!nt) {
                dw_entry_free(&e);
                goto oom;
            }
            tmp = nt;
            tmp_cap = nc;
        }
        tmp[tmp_len++] = e;
    }

    if (tmp_len == 0) {
        free(tmp);
        return ESP_ERR_NOT_FOUND;
    }
    if (unlabeled) {
        /* A catalog seeded by pre-i18n firmware keeps surviving boots (editing
         * /data/config/devices.csv by hand is a supported path, so the loader
         * must not reject it), but its rows have style_json.label and no labels
         * map: every card then shows the technical parameter name. */
        ESP_LOGW(TAG, "%u catalog row(s) have no style_json.labels; re-upload "
                      "model/*.csv (PUT /api/dev/catalog/) or delete "
                      MINIHUB_DW_CSV_PATH " to get the localized registry",
                 (unsigned)unlabeled);
    }

    /* Drop rows that look like a shifted/corrupt parse. A CSV written by an
     * older firmware with a different quoting style shifts columns at the
     * embedded commas inside the style JSON: rows still parse "successfully"
     * but carry garbage (image paths / raw JSON fragments / localized labels
     * in `parameter`, truncated `style`).
     * Only the offending rows go, and they are counted: rejecting the whole
     * file used to cost the user EVERY other hand-made edit, because the
     * caller then fell back to the embedded registry and re-seeded
     * /data/config/devices.csv. When nothing survives, the file is still
     * rejected so that fall-back path stays intact. */
    size_t dropped = 0;
    for (size_t i = 0; i < tmp_len; ) {
        const char *p = tmp[i].parameter;
        const char *s = tmp[i].style_json;
        bool bad = (p == NULL || p[0] == '\0');
        if (!bad) {
            for (const unsigned char *c = (const unsigned char *)p; *c; c++) {
                if (!((*c >= 'a' && *c <= 'z') || (*c >= 'A' && *c <= 'Z') ||
                      (*c >= '0' && *c <= '9') || *c == '_' || *c == '-')) {
                    bad = true;
                    break;
                }
            }
        }
        if (!bad) {
            cJSON *root = (s && s[0]) ? cJSON_Parse(s) : NULL;
            cJSON *w = root ? cJSON_GetObjectItemCaseSensitive(root, "widget") : NULL;
            bad = (root == NULL || !cJSON_IsString(w) || !w->valuestring ||
                   w->valuestring[0] == '\0');
            cJSON_Delete(root);
        }
        if (!bad) {
            i++;
            continue;
        }
        ESP_LOGW(TAG, "dropping corrupt registry row (param '%.32s')", p ? p : "");
        dw_entry_free(&tmp[i]);
        memmove(&tmp[i], &tmp[i + 1], (tmp_len - i - 1) * sizeof(*tmp));
        tmp_len--;
        dropped++;
    }
    if (dropped) {
        ESP_LOGW(TAG, "registry loaded with %u corrupt row(s) dropped",
                 (unsigned)dropped);
    }
    if (tmp_len == 0) {
        /* Not a single usable row: treat the file as unusable. */
        free(tmp);
        return ESP_ERR_INVALID_ARG;
    }

    qsort(tmp, tmp_len, sizeof(*tmp), dw_entry_cmp);

    /* count distinct devices (now grouped by the sort) */
    size_t devs = 1;
    for (size_t i = 1; i < tmp_len; i++) {
        if (strcmp(tmp[i].device, tmp[i - 1].device) != 0) {
            devs++;
        }
    }

    minihub_device_widget_device_t *views = malloc(devs * sizeof(*views));
    if (!views) {
        goto oom;
    }

    size_t v = 0, i = 0;
    while (i < tmp_len) {
        size_t start = i;
        const char *dev = tmp[i].device;
        /* The device-class icon override is repeated on every row of the
         * device (the registry is flat), so any row carrying it wins. */
        const char *dimg = "";
        while (i < tmp_len && strcmp(tmp[i].device, dev) == 0) {
            if (dimg[0] == '\0' && tmp[i].device_image[0]) {
                dimg = tmp[i].device_image;
            }
            i++;
        }
        views[v].device = dev;
        views[v].entries = (const minihub_device_widget_entry_t *)&tmp[start];
        views[v].count = i - start;
        views[v].image = dimg;
        v++;
    }

    out->entries = tmp;       /* ownership transferred: strings owned here */
    out->entries_len = tmp_len;
    out->views = views;
    out->views_len = v;
    ESP_LOGI(TAG, "registry built: %u entries, %u device types",
             (unsigned)out->entries_len, (unsigned)out->views_len);
    return ESP_OK;

oom:
    ESP_LOGE(TAG, "device widget build failed (out of memory)");
    if (tmp) {
        for (size_t k = 0; k < tmp_len; k++) {
            free(tmp[k].device);
            free(tmp[k].parameter);
            free(tmp[k].label);
            free(tmp[k].style_json);
            free(tmp[k].image);
            free(tmp[k].device_image);
        }
        free(tmp);
    }
    return ESP_ERR_NO_MEM;
}

/* ---- file / load entry points ---- */

static char *dw_read_file(const char *path, size_t *out_len)
{
    FILE *f = fopen(path, "rb");
    if (!f) {
        return NULL;
    }
    if (fseek(f, 0, SEEK_END) != 0) {
        fclose(f);
        return NULL;
    }
    long sz = ftell(f);
    if (sz < 0) {
        fclose(f);
        return NULL;
    }
    fseek(f, 0, SEEK_SET);
    char *buf = malloc((size_t)sz + 1);
    if (!buf) {
        fclose(f);
        return NULL;
    }
    size_t rd = fread(buf, 1, (size_t)sz, f);
    fclose(f);
    buf[rd] = '\0';
    *out_len = rd;
    return buf;
}

/* Copy `requires` from the embedded registry into an on-disk row that predates
 * that field. A user-uploaded model/parameters.csv owns the catalog and is
 * left alone. Custom device rows that are not in the embedded table are too.
 * Does not rewrite the file — only the in-memory style the UI reads. */
static void dw_overlay_embedded_requires(dw_table_t *loaded)
{
    FILE *model = fopen(MINIHUB_DW_MODEL_PARAMETERS_PATH, "rb");
    if (model) {
        fclose(model);
        return;
    }
    dw_table_t emb = {0};
    if (dw_build(MINIHUB_DW_EMBEDDED_CSV, &emb) != ESP_OK) {
        return;
    }
    unsigned filled = 0;
    for (size_t i = 0; i < loaded->entries_len; i++) {
        dw_entry_t *e = &loaded->entries[i];
        const dw_entry_t *src = NULL;
        for (size_t j = 0; j < emb.entries_len; j++) {
            if (strcmp(emb.entries[j].device, e->device) == 0 &&
                strcmp(emb.entries[j].parameter, e->parameter) == 0) {
                src = &emb.entries[j];
                break;
            }
        }
        if (!src) {
            continue;
        }
        cJSON *src_style = cJSON_Parse(src->style_json);
        if (!src_style) {
            continue;
        }
        cJSON *req = cJSON_GetObjectItemCaseSensitive(src_style, "requires");
        if (!req) {
            cJSON_Delete(src_style);
            continue;
        }
        cJSON *dst = cJSON_Parse(e->style_json ? e->style_json : "{}");
        if (dst && cJSON_GetObjectItemCaseSensitive(dst, "requires")) {
            cJSON_Delete(dst);
            cJSON_Delete(src_style);
            continue;
        }
        if (!dst) {
            dst = cJSON_CreateObject();
        }
        if (!dst) {
            cJSON_Delete(src_style);
            continue;
        }
        cJSON *dup = cJSON_Duplicate(req, true);
        cJSON_Delete(src_style);
        if (!dup) {
            cJSON_Delete(dst);
            continue;
        }
        cJSON_AddItemToObject(dst, "requires", dup);
        char *merged = cJSON_PrintUnformatted(dst);
        cJSON_Delete(dst);
        if (!merged) {
            continue;
        }
        free(e->style_json);
        e->style_json = merged;
        filled++;
    }
    dw_table_free(&emb);
    if (filled) {
        ESP_LOGI(TAG, "filled requires on %u catalog rows from embedded registry", filled);
    }
}

/* Build a table from `path` (or from the compiled-in registry when path is
 * NULL/empty). Nothing is published here: callers decide what to do on failure. */
static esp_err_t dw_build_path(const char *path, dw_table_t *out)
{
    if (!path || !path[0]) {
        return dw_build(MINIHUB_DW_EMBEDDED_CSV, out);
    }
    size_t len = 0;
    char *fb = dw_read_file(path, &len);
    if (!fb) {
        return ESP_ERR_NOT_FOUND;
    }
    esp_err_t err = dw_build(fb, out);
    free(fb);
    if (err == ESP_OK) {
        dw_overlay_embedded_requires(out);
    }
    return err;
}

esp_err_t minihub_device_widget_load(const char *path)
{
    dw_table_t next = {0};
    esp_err_t err = dw_build_path(path, &next);
    if (err != ESP_OK) {
        return err;
    }
    dw_publish(&next);
    return ESP_OK;
}

/* Forward declaration (defined just below). */
static void dw_seed_file(void);

esp_err_t minihub_device_widget_init(void)
{
    if (s_loaded) {
        return ESP_OK;   /* idempotent */
    }
    /* If both model CSVs are already on disk (a dev_sync upload), rewrite the
     * flat catalog with this firmware before loading it. An older build can
     * store the source files and still emit styles that omit `requires`. */
    {
        char flat_err[128];
        esp_err_t ferr = minihub_device_widget_flatten_stored_model(flat_err, sizeof(flat_err));
        if (ferr == ESP_OK) {
            ESP_LOGI(TAG, "flattened stored model csv into %s", MINIHUB_DW_CSV_PATH);
        } else if (ferr != ESP_ERR_NOT_FOUND) {
            ESP_LOGW(TAG, "stored model csv not flattened: %s",
                     flat_err[0] ? flat_err : "failed");
        }
    }
    /* Seed the embedded registry onto /data/config so it is visible and editable
     * at runtime (new device types = edit the CSV, no reflash). If the file
     * already exists we keep it, then fill any stock row that is missing
     * `requires` from the embedded registry (unless a model/parameters.csv
     * upload owns the catalog). */
    FILE *t = fopen(MINIHUB_DW_CSV_PATH, "rb");
    if (!t) {
        dw_seed_file();
    } else {
        fclose(t);
    }
    esp_err_t err = minihub_device_widget_load(MINIHUB_DW_CSV_PATH);
    if (err != ESP_OK) {
        ESP_LOGW(TAG, "CSV load from %s failed (%d); re-seeding embedded registry",
                 MINIHUB_DW_CSV_PATH, err);
        /* Overwrite the rejected/corrupt file so the next boot loads the
         * good embedded registry directly instead of failing again. */
        dw_seed_file();
        err = minihub_device_widget_load(MINIHUB_DW_CSV_PATH);
        if (err != ESP_OK) {
            /* Seed write failed (read-only FS?) — still boot from ROM copy. */
            err = minihub_device_widget_load(NULL);
        }
    }
    return err;
}

/* Write the compiled-in fallback CSV to MINIHUB_DW_CSV_PATH (creating the
 * parent directory). Called once at first boot when no external CSV exists. */
static void dw_seed_file(void)
{
    char dir[128];
    snprintf(dir, sizeof(dir), "%s", MINIHUB_DW_CSV_PATH);
    char *slash = strrchr(dir, '/');
    if (slash) {
        *slash = '\0';
        mkdir(dir, 0755);   /* ignore EEXIST */
    }
    FILE *f = fopen(MINIHUB_DW_CSV_PATH, "wb");
    if (!f) {
        ESP_LOGW(TAG, "cannot seed %s (read-only FS?)", MINIHUB_DW_CSV_PATH);
        return;
    }
    size_t n = strlen(MINIHUB_DW_EMBEDDED_CSV);
    size_t w = fwrite(MINIHUB_DW_EMBEDDED_CSV, 1, n, f);
    fclose(f);
    if (w == n) {
        ESP_LOGI(TAG, "seeded %s (%u bytes) from embedded registry",
                 MINIHUB_DW_CSV_PATH, (unsigned)n);
    } else {
        ESP_LOGW(TAG, "short write seeding %s", MINIHUB_DW_CSV_PATH);
    }
}

esp_err_t minihub_device_widget_reload(const char *path)
{
    const char *p = path ? path : MINIHUB_DW_CSV_PATH;
    dw_table_t next = {0};

    /* Build the replacement FIRST and only publish it when it parses: the old
     * table keeps serving concurrent readers (and stays up if the new CSV is
     * broken), instead of being free()d up front as it used to be. */
    esp_err_t err = dw_build_path(p, &next);
    if (err == ESP_OK) {
        dw_publish(&next);
        return ESP_OK;
    }
    ESP_LOGW(TAG, "reload from %s failed (%d); keeping previous registry",
             p, err);
    /* Self-heal: rewrite the rejected/corrupt file from the embedded registry
     * so the next boot loads a good copy directly. */
    dw_seed_file();
    err = dw_build_path(MINIHUB_DW_CSV_PATH, &next);
    if (err == ESP_OK) {
        dw_publish(&next);
        return ESP_OK;
    }
    err = dw_build_path(NULL, &next);
    if (err == ESP_OK) {
        ESP_LOGW(TAG, "registry fell back to the embedded CSV");
        dw_publish(&next);
    }
    /* On total failure the previously loaded table is still served - an empty
     * registry would blank every device card in the console. */
    return err;
}

void minihub_device_widget_free(void)
{
    dw_lock();
    dw_table_free(&s_active);
    dw_table_free(&s_retired);
    s_loaded = false;
    dw_unlock();
}

/* ---- queries ---- */

/* Locked internals: image_name() and find() must be able to look up twice
 * (find() calls get()) without re-taking the non-recursive mutex. */
static const minihub_device_widget_device_t *dw_get_locked(const char *device)
{
    if (!device) {
        return NULL;
    }
    for (size_t i = 0; i < s_active.views_len; i++) {
        if (strcmp(s_active.views[i].device, device) == 0) {
            return &s_active.views[i];
        }
    }
    return NULL;
}

static const minihub_device_widget_entry_t *dw_find_locked(const char *device,
                                                           const char *parameter)
{
    const minihub_device_widget_device_t *d = dw_get_locked(device);
    if (!d || !parameter) {
        return NULL;
    }
    for (size_t i = 0; i < d->count; i++) {
        if (strcmp(d->entries[i].parameter, parameter) == 0) {
            return &d->entries[i];
        }
    }
    return NULL;
}

/* The returned pointer stays valid after the lock is dropped: the snapshot it
 * points into is only released one reload later (see dw_publish). */
const minihub_device_widget_device_t *
minihub_device_widget_get(const char *device)
{
    dw_lock();
    const minihub_device_widget_device_t *d = dw_get_locked(device);
    dw_unlock();
    return d;
}

const minihub_device_widget_device_t *
minihub_device_widget_device_at(size_t index)
{
    dw_lock();
    const minihub_device_widget_device_t *d =
        (index < s_active.views_len) ? &s_active.views[index] : NULL;
    dw_unlock();
    return d;
}

const minihub_device_widget_entry_t *
minihub_device_widget_find(const char *device, const char *parameter)
{
    dw_lock();
    const minihub_device_widget_entry_t *e = dw_find_locked(device, parameter);
    dw_unlock();
    return e;
}

size_t minihub_device_widget_device_count(void)
{
    dw_lock();
    size_t n = s_active.views_len;
    dw_unlock();
    return n;
}

size_t minihub_device_widget_entry_count(void)
{
    dw_lock();
    size_t n = s_active.entries_len;
    dw_unlock();
    return n;
}

char *minihub_device_widget_path(const char *prefix,
                                 const char *device,
                                 const char *parameter,
                                 char *buf, size_t size)
{
    if (!buf || size == 0 || !device || !parameter) {
        return NULL;
    }
    int n = (prefix && *prefix)
                ? snprintf(buf, size, "%s.%s.%s", prefix, device, parameter)
                : snprintf(buf, size, "%s.%s", device, parameter);
    if (n < 0 || (size_t)n >= size) {
        return NULL;  /* truncated or encoding error */
    }
    return buf;
}

char *minihub_device_widget_report_payload(uint32_t seq,
                                           const char *device,
                                           const char *parameter,
                                           const char *value_json,
                                           char *buf, size_t size)
{
    if (!buf || size == 0 || !device || !parameter) {
        return NULL;
    }
    const char *v = value_json ? value_json : "";
    /* seq is the FIRST key; device/parameter identify the target; value is the
     * already-JSON payload. The transport address (<protocol>.<device>.<param>)
     * is NOT built here: this catalog is protocol-agnostic, the caller resolves
     * the registered point_id instead. */
    int n = snprintf(buf, size,
                     "{\"seq\":%u,\"device\":\"%s\",\"parameter\":\"%s\",\"value\":%s}",
                     (unsigned)seq, device, parameter, v);
    if (n < 0 || (size_t)n >= size) {
        return NULL;  /* truncated */
    }
    return buf;
}

/* ---- icon lookup ---- */

/* Icon directory in storage: MINIHUB_DW_IMAGES_DIR from minihub_device_widget.h
 * (overridable for tests / host builds via -D). Below it the icons are split by
 * what they depict:
 *   <dir>/devices/<device>.svg                  device-class icon (avatar)
 *   <dir>/parameters/<device>_<parameter>.svg   control icon (mockup)
 * The resolved value is returned as "<subdir>/<name>", i.e. relative to
 * MINIHUB_DW_IMAGES_DIR, so it drops straight into the /img/ URI. */

/* Longest accepted icon file name (device + parameter + ".svg"). */
#define DW_IMAGE_NAME_MAX 64

/* A candidate is only accepted when it is a plain file name: no path
 * separators, no NUL/control chars. Keeps a user-edited devices.csv from
 * escaping MINIHUB_DW_IMAGES_DIR - the sub-directory is always chosen by the
 * resolver, never by the CSV. */
static bool dw_image_name_ok(const char *name)
{
    if (!name || !name[0] || strlen(name) >= DW_IMAGE_NAME_MAX) {
        return false;
    }
    for (const char *p = name; *p; p++) {
        unsigned char c = (unsigned char)*p;
        if (!((c >= 'a' && c <= 'z') || (c >= 'A' && c <= 'Z') ||
              (c >= '0' && c <= '9') || c == '_' || c == '-' || c == '.')) {
            return false;
        }
    }
    return true;
}

/* Parameter ids may carry a hyphen while icon file names are underscore-only,
 * so a "-" in the id maps to "_" when resolving the file. */
static void dw_image_norm(const char *in, char *out, size_t size)
{
    size_t i = 0;
    if (!in || size == 0) {
        return;
    }
    for (; in[i] && i + 1 < size; i++) {
        out[i] = (in[i] == '-') ? '_' : in[i];
    }
    out[i] = '\0';
}

/* Is <storage>/images/<subdir>/<name> an existing regular file? */
static bool dw_image_file_exists(const char *subdir, const char *name)
{
    char path[DW_IMAGE_NAME_MAX + 64];
    struct stat st;
    if (snprintf(path, sizeof(path), "%s/%s/%s", MINIHUB_DW_IMAGES_DIR, subdir,
                 name) >= (int)sizeof(path)) {
        return false;
    }
    return stat(path, &st) == 0 && S_ISREG(st.st_mode);
}

/* Accept a candidate: only when the file is really there AND the relative
 * "<subdir>/<name>" path fits the caller's buffer (an icon that cannot be
 * reported is useless). */
static bool dw_image_take(const char *subdir, const char *name,
                          char *buf, size_t size)
{
    if (!dw_image_file_exists(subdir, name)) {
        return false;
    }
    int n = snprintf(buf, size, "%s/%s", subdir, name);
    return n >= 0 && (size_t)n < size;
}

char *minihub_device_widget_image_name(const char *device,
                                       const char *parameter,
                                       char *buf, size_t size)
{
    if (!buf || size == 0 || !device || !device[0]) {
        return NULL;
    }
    buf[0] = '\0';

    char dev[DW_IMAGE_NAME_MAX] = {0};
    char par[DW_IMAGE_NAME_MAX] = {0};
    dw_image_norm(device, dev, sizeof(dev));
    dw_image_norm(parameter, par, sizeof(par));

    /* Take the two catalog overrides under the lock, then release it before
     * touching the filesystem: stat() on littlefs can block, and it must not
     * delay a concurrent reload. */
    char dev_img[DW_IMAGE_NAME_MAX] = {0};
    char par_img[DW_IMAGE_NAME_MAX] = {0};
    dw_lock();
    const minihub_device_widget_device_t *d = dw_get_locked(device);
    if (d && d->image) {
        snprintf(dev_img, sizeof(dev_img), "%s", d->image);
    }
    if (par[0]) {
        const minihub_device_widget_entry_t *e = dw_find_locked(device, parameter);
        if (e && e->image) {
            snprintf(par_img, sizeof(par_img), "%s", e->image);
        }
    }
    dw_unlock();

    /* No parameter -> device-class icon (avatar), under <dir>/devices/. */
    if (!par[0]) {
        if (dev_img[0]) {
            const char *base = strrchr(dev_img, '/');
            base = base ? base + 1 : dev_img;
            if (dw_image_name_ok(base) &&
                dw_image_take(MINIHUB_DW_IMAGES_DEVICES_SUBDIR, base, buf, size)) {
                return buf;
            }
        }
        char dname[DW_IMAGE_NAME_MAX];
        if (snprintf(dname, sizeof(dname), "%s.svg", dev) < (int)sizeof(dname) &&
            dw_image_take(MINIHUB_DW_IMAGES_DEVICES_SUBDIR, dname, buf, size)) {
            return buf;
        }
        buf[0] = '\0';
        return NULL;
    }

    /* Control icon candidates, first hit wins (see header for the contract):
     *   1. explicit `image` column of the (device, parameter) row. The stored
     *      value is a bare file name; a legacy "images/foo.svg" path is
     *      tolerated by looking at the basename only (the sub-directory always
     *      comes from the resolver, never from the CSV).
     *   2. <device>_<parameter>.svg   e.g. light_brightness.svg
     *   3. <parameter>.svg            shared icon for the parameter name
     * All of them live under <dir>/parameters/; a control never falls back to
     * the device-class icon - that one is an avatar, not a control mockup. */
    if (par_img[0]) {
        const char *base = strrchr(par_img, '/');
        base = base ? base + 1 : par_img;
        if (dw_image_name_ok(base) &&
            dw_image_take(MINIHUB_DW_IMAGES_PARAMETERS_SUBDIR, base, buf, size)) {
            return buf;
        }
    }

    char cand[DW_IMAGE_NAME_MAX];
    if (dev[0]) {
        if (snprintf(cand, sizeof(cand), "%s_%s.svg", dev, par) < (int)sizeof(cand) &&
            dw_image_take(MINIHUB_DW_IMAGES_PARAMETERS_SUBDIR, cand, buf, size)) {
            return buf;
        }
    }
    if (snprintf(cand, sizeof(cand), "%s.svg", par) < (int)sizeof(cand) &&
        dw_image_take(MINIHUB_DW_IMAGES_PARAMETERS_SUBDIR, cand, buf, size)) {
        return buf;
    }

    buf[0] = '\0';
    return NULL;
}
